File: Plate/PlateV1/Plate/Plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 377 x 127.2 mm, 0 parts

Commit message: Updates
Other:
- board size 377 x 127.2 mm -> 375.3 x 124.5 mm
